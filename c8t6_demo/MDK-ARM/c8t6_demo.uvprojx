# Keil uVision project c8t6_demo.uvprojx, settings and files
target c8t6_demo (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../ark_sdk/hal/include;../../../ark_sdk/component/common;../../../ark_sdk/component/icm20602;../../../ark_sdk/component/led;../../../ark_sdk/component/motor;../../../ark_sdk/component/oled;../../../ark_sdk/component/stream;../../../ark_sdk/component/uart_cli;../../../ark_sdk/component/watchdog;../../../ark_sdk/component/flash;../../../ark_sdk/component/ws2812b;../../../ark_sdk/app/microcar/include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group ARK_SDK/HAL
    ../../../ark_sdk/hal/stm32f1/src/: ark_hal_gpio.c ark_hal_can.c ark_hal_i2c.c ark_hal_pwm.c ark_hal_spi.c ark_hal_uart.c ark_hal_watchdog.c
    ../../../ark_sdk/hal/src/: ark_uart_manage.c
  group ARK_SDK/Components
    ../../../ark_sdk/component/common/: ark_cli.c ark_component.c ark_dts.c ark_stream.c ark_uart_codec.c
    ../../../ark_sdk/component/icm20602/: icm20602.c
    ../../../ark_sdk/component/led/: led.c
    ../../../ark_sdk/component/motor/: motor.c
    ../../../ark_sdk/component/oled/: oled.c ssd1306.c
    ../../../ark_sdk/component/stream/: stream.c
    ../../../ark_sdk/component/uart_cli/: uart_cli.c
    ../../../ark_sdk/component/watchdog/: watchdog.c
    ../../../ark_sdk/component/flash/: flash.c
    ../../../ark_sdk/component/ws2812b/: ws2812b.c
  group ARK_SDK/App
    ../../../ark_sdk/app/microcar/src/: app_component_boot.c app_main.c app_sys_config.c
software components: CMSIS:CORE 6.2.0
