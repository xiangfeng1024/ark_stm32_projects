# Keil uVision project c8t6_microcar_soil.uvprojx, settings and files
target c8t6_microcar_soil (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x0000FC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6_microcar_soil +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../ark_sdk/hal/include;../../../ark_sdk/component/common;../../../ark_sdk/component/adc38_tracking;../../../ark_sdk/component/adc_sensor;../../../ark_sdk/component/beidou;../../../ark_sdk/component/bh1750;../../../ark_sdk/component/bluetooth;../../../ark_sdk/component/buzzer;../../../ark_sdk/component/control;../../../ark_sdk/component/dht11;../../../ark_sdk/component/encoder;../../../ark_sdk/component/flash;../../../ark_sdk/component/maixcam;../../../ark_sdk/component/motor;../../../ark_sdk/component/oled;../../../ark_sdk/component/servo;../../../ark_sdk/component/stream;../../../ark_sdk/component/ws2812b;../../../ark_sdk/app/c8t6_microcar_soil/include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xFC00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group ARK_SDK/HAL
    ../../../ark_sdk/hal/stm32f1/src/: ark_hal_adc.c ark_hal_encoder.c ark_hal_gpio.c ark_hal_i2c.c ark_hal_pwm.c ark_hal_time.c ark_hal_uart.c
    ../../../ark_sdk/hal/src/: ark_uart_manage.c
  group ARK_SDK/Components
    ../../../ark_sdk/component/common/: ark_cli.c ark_component.c ark_dts.c ark_stream.c ark_uart_codec.c
    ../../../ark_sdk/component/adc38_tracking/: adc38_tracking.c
    ../../../ark_sdk/component/adc_sensor/: adc_sensor.c
    ../../../ark_sdk/component/beidou/: beidou.c
    ../../../ark_sdk/component/bh1750/: bh1750.c
    ../../../ark_sdk/component/bluetooth/: bluetooth.c
    ../../../ark_sdk/component/buzzer/: buzzer.c
    ../../../ark_sdk/component/control/: control.c control_pid.c control_line_tracking.c
    ../../../ark_sdk/component/dht11/: dht11.c
    ../../../ark_sdk/component/encoder/: encoder.c
    ../../../ark_sdk/component/flash/: flash.c flash_stm32f103.c
    ../../../ark_sdk/component/maixcam/: maixcam.c
    ../../../ark_sdk/component/motor/: motor.c motor_tb6612.c
    ../../../ark_sdk/component/oled/: oled.c ssd1306.c
    ../../../ark_sdk/component/servo/: servo.c
    ../../../ark_sdk/component/stream/: stream.c
    ../../../ark_sdk/component/ws2812b/: ws2812b.c
  group ARK_SDK/App
    ../../../ark_sdk/app/c8t6_microcar_soil/src/: app_component_boot.c app_dts_config.c app_flower_tracking.c app_line_follow.c app_main.c app_soil_probe.c app_tracking_calibration.c ark_dts_generated.c
software components: CMSIS:CORE 6.2.0
